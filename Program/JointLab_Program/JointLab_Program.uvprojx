# Keil uVision project JointLab_Program.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: straight +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  memory RVCT10: RAM 0x20001000 size 0x4000
  scatter file: .\Objects\straight.sct
  group Source Group 1
    ./: main.cpp wheel.h uart2.h wheel.o uart2.o control.cpp
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
